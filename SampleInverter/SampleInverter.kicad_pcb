# Repository IR2110/VVVF_ArduinoMicro

File README.md:

# Arduino MicroでVVVF
「インバータ技術2025年12月号 中学生でも作れる！VVVFインバータの創り方」 付属サンプルプログラム集

# 各プログラムの概要
## Pwm_1kHz
ファイルパス: `Pwm_1kHz/Pwm_1kHz.ino`

Arduino Microで1kHz、デューティ比50%のPWM信号を生成。

## Timer_Interrupt
ファイルパス: `Timer_Interrupt/Timer_Interrupt.ino`

タイマ割り込みを使って0.1sごとに13番ピン（緑色LED）をチカチカする。いわゆるLチカ。

## VVVF_test1
ファイルパス: `VVVF_test1/VVVF_test1.ino`

3相PWMのテスト用プログラム。位相アキュムレータ知らない感じで実装してるので周波数分解能が7.8Hz。波形としてはそれっぽいけど多分ぶっ壊れるので使わないでね。

## VVVF_test2
ファイルパス: `VVVF_test2/VVVF_test2.ino`

正式な3相PWM生成用プログラム。位相アキュムレータとかちゃんとしたバージョン。

## VVVF_Completed
ファイルパス: `VVVF_Completed/VVVF_Completed.ino`

THI・SVMや電圧補償係数の実装もしてあるArduino Microで非同期PWMを出すためにいろいろ頑張ったやつ。発展型。

## SampleInverter
ファイルパス: `SampleInverter/SampleInverter.kicad_pro`

本書で作ったインバータのサンプルプロジェクト

## KiCad design SampleInverter/SampleInverter.kicad_pcb

Parts:
C8, C9, C10, C13, C14, C18, C19, C20, C21, C29, C32, C33: 0.1u; C_0603_1608Metric
C11, C12: 470u; CP_Radial_D35.0mm_P10.00mm_SnapIn
C15, C16, C24, C25, C27, C28: 470p; C_Disc_D7.0mm_W2.5mm_P5.00mm
C17, C26, C31: 1u; C_Rect_L24.0mm_W12.8mm_P22.50mm_MKT
C22, C23, C34: 10u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C30: 100u; CP_Radial_D6.3mm_P2.50mm
D1: GBU8D; Diode_Bridge_Vishay_GBU
D2, D3, D4: UF2010; D_DO-15_P10.16mm_Horizontal
F1: 250V 5A; Fuseholder_Clip-5x20mm_Keystone_3517_Inline_P23.11x6.76mm_D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
J1: L; AK-PCB-20(632F)
J2: N; AK-PCB-20(632F)
J4, J6: Terminal_Block; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
J5: Jack_DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
J7: U; AK-PCB-20(632F)
J8: V; AK-PCB-20(632F)
J9: W; AK-PCB-20(632F)
Q1, Q2, Q3, Q4, Q5, Q6: TK10A60D; TO-220-3_Vertical
R2, R3, R4: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6, R7, R8, R19, R20: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R15, R16, R17, R18: 10; D_2512_6332Metric_Pad1.52x3.35mm_HandSolder
R11, R12, R13, R14, R21, R22: 10; R_2512_6332Metric
RV1: 1k; TerminalBlock_MaiXu_MX126-5.0-03P_1x03_P5.00mm
TH1: Thermistor_NTC_US; NTPAN1R0LDKB0
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19: TestPoint; TestPoint_Loop_D2.50mm_Drill1.0mm
U1: Arduino Micro; ARDUINO_A000053; PARTREV N/A
U2, U3, U4, U7, U8, U9, U10, U12, U13: TLP152
U5, U6, U11: IR2302; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
G15V: C8.2, C9.2, C10.2, C13.2, C14.2, C18.2, C19.2, C29.2, C30.1, C32.2, D2.2 (A), D3.2 (A), D4.2 (A), J5.1, J6.2, U2.6, U3.6, U4.6, U5.1 (VCC), U5.8 (VB), U6.1 (VCC), U6.8 (VB), U8.6, U10.6, U11.1 (VCC), U11.8 (VB), U13.6
G_{UH}: Q1.1 (G), R13.2, TP7.1
G_{UL}: Q2.1 (G), R11.2, TP9.1
G_{VH}: Q3.1 (G), R22.2, TP11.1
G_{VL}: Q4.1 (G), R21.2, TP13.1
G_{WH}: Q5.1 (G), R14.2, TP15.1
G_{WL}: Q6.1 (G), R12.2, TP17.1
L5V: J4.2, RV1.1, U1.29 (+5V)
LG: J4.1, RV1.3, TP19.1, U1.6 (GND), U1.31 (GND__1), U2.2, U3.2, U4.2
unnamed: C15.2, R9.1
unnamed: C16.2, R10.1
unnamed: C24.2, R15.1
unnamed: C25.2, R16.1
unnamed: C27.2, R17.1
unnamed: C28.2, R18.1
unnamed: C11.1, C15.1, C17.1, C24.1, C26.1, C27.1, C31.1, D1.1 (+), Q1.2 (D), Q3.2 (D), Q5.2 (D)
unnamed: D1.3, TH1.2
unnamed: C20.2, C22.2, D2.1 (K), U7.6
unnamed: C21.2, C23.2, D3.1 (K), U9.6
unnamed: C33.2, C34.2, D4.1 (K), U12.6
unnamed: F1.2, TH1.1
unnamed: F1.1, J1.1
unnamed: C11.2, C12.1, D1.2, J2.1
unnamed: R2.2, U2.1
unnamed: R3.2, U3.1
unnamed: R4.2, U4.1
unnamed: R5.2, U8.1
unnamed: R6.2, U10.1
unnamed: R7.2, U7.1
unnamed: R8.2, U9.1
unnamed: R11.1, U8.5
unnamed: R12.1, U10.5
unnamed: R13.1, U7.5
unnamed: R14.1, U9.5
unnamed: R19.2, U13.1
unnamed: R20.2, U12.1
unnamed: R21.1, U13.5
unnamed: R22.1, U12.5
unnamed: RV1.2, U1.21 (A0)
unnamed: R7.1, U5.7 (HO)
unnamed: R5.1, U5.5 (LO)
unnamed: R8.1, U6.7 (HO)
unnamed: R6.1, U6.5 (LO)
unnamed: R20.1, U11.7 (HO)
unnamed: R19.1, U11.5 (LO)
PG: C8.1, C9.1, C10.1, C12.2, C13.1, C14.1, C17.2, C18.1, C19.1, C26.2, C29.1, C30.2, C31.2, C32.1, D1.4 (-), J5.2, J5.3, J6.1, Q2.3 (S), Q4.3 (S), Q6.3 (S), R10.2, R16.2, R18.2, TP10.1, TP14.1, TP18.1, U2.4, U3.4, U4.4, U5.4 (COM), U5.6 (VS), U6.4 (COM), U6.6 (VS), U7.2, U8.2, U8.4, U9.2, U10.2, U10.4, U11.4 (COM), U11.6 (VS), U12.2, U13.2, U13.4
S_{UH}: C16.1, C20.1, C22.1, J7.1, Q1.3 (S), Q2.2 (D), R9.2, TP8.1, U7.4
S_{VH}: C25.1, C33.1, C34.1, J8.1, Q3.3 (S), Q4.2 (D), R15.2, TP12.1, U12.4
S_{WH}: C21.1, C23.1, C28.1, J9.1, Q5.3 (S), Q6.2 (D), R17.2, TP16.1, U9.4
U: TP4.1, U2.5, U5.2 (IN)
U_{LOGIC}: R2.1, TP1.1, U1.14 (9(PWM)/A9)
V: TP5.1, U3.5, U11.2 (IN)
V_{LOGIC}: R3.1, TP2.1, U1.15 (10(PWM)/A10)
W: TP6.1, U4.5, U6.2 (IN)
W_{LOGIC}: R4.1, TP3.1, U1.16 (11(PWM))

Notes on the sheet:
速度指令用ポテンショメータ→
Arduino
倍電圧整流回路
インバータ主回路
デッドタイム生成&ゲート・ドライバ
Arduinoとの絶縁

Board: 2 copper layers, 188.0 x 72.3 mm, 101 parts (12 on the bottom side), 55 nets.

## Commit log

2025-08-07 init
2025-08-07 1455
2025-08-07 324532
2025-08-07 wqeqwe
2025-08-07 3253463
2025-08-07 435345
2025-08-07 45635
2025-08-07 34567890
2025-08-07 Refactor wave function in lut.py and m2a.py; update SVM calculation and comment out unused code. Add VSCode settings and output CSV with generated data.
2025-08-07 fix: update ISR to call update function for timer 3
    VVVF_ArduinoMicro.inoのTIMER3_COMPA割り込み処理を修正。update関数を呼び出すように変更し、fSigとmVoltageの更新を適切に行うようにした。
2025-08-07 fix: update update function comment for clarity
    VVVF_ArduinoMicro.inoのupdate関数のコメントを修正。samplingRate [Hz]に基づく呼び出しを明示化。
2025-08-07 fix: update comment for clarity in update_duties_and_set_ocr function
    VVVF_ArduinoMicro.inoのupdate_duties_and_set_ocr関数内のコメントを明確化
2025-08-07 fix: update duties and OCR assignment logic
    VVVF_ArduinoMicro.inoのupdate_duties_and_set_ocr関数において、OCRの計算を簡素化し、過変調によるタイマの破損を防ぐための制限を追加。settings.jsonにファイルの関連付けを追加。
2025-08-07 fix: update signal increment logic in update function
    VVVF_ArduinoMicro.inoのupdate関数において、信号の増加ロジックを修正。samplingRateに基づく計算式に変更。
2025-08-07 fix: コメントの表記を統一
    VVVF_ArduinoMicro.inoのコメントを修正し、カッコの表記を統一。
2025-08-07 feat: PWMコントローラの実装
    - ModController.hを削除
    - pwm_controller.hを新規作成し、PWM設定と電圧補償係数計算の関数を追加
    - VVVF_ArduinoMicro.inoのインクルードファイルを修正
    - settings.jsonのincludePathにworkspaceFolderを追加
2025-08-07 fix: コメントの修正とISRの整理
    - 位相アキュムレータのコメントを修正
    - update関数をTIMER3_COMPAのISRで呼び出すように追加
    - TIMER1のISR内のupdate_duties_and_set_ocr呼び出しを整理
2025-08-07 Refactor duty cycle calculations and voltage coefficient logic
    - Simplified the calculation of duty cycles for phases U, V, and W in the update_duties_and_set_ocr function by condensing multiple lines into single-line expressions for better readability.
    - Streamlined the calculate_voltage_coefficient function by reducing the number of lines in the conditional statements, improving clarity while maintaining functionality.
    - Ensured consistent formatting and removed unnecessary line breaks in the pwm_controller.h file.
2025-08-07 fix: PWM出力の計算ロジックの修正
    VVVF_ArduinoMicro.ino:
    - PWM出力の計算を修正し、出力範囲をpm_hold.topに基づいて制限
    - duty_u, duty_v, duty_wの型をfloatからuint16_tに変更
    lut.py:
    - wave関数内の戻り値を修正し、正弦波の計算を調整
    - my_dataのスケーリングを修正
2025-08-08 fix: update_duties_and_set_ocr関数内のコメント修正
    update_duties_and_set_ocr関数内のpm_holdの初期化コメントを修正し、可読性を向上させた。
2025-08-08 fix: update_duties_and_set_ocr関数の不要な空行削除
    VVVF_ArduinoMicro.inoファイルのupdate_duties_and_set_ocr関数内の不要な空行を削除
2025-08-08 Refactor to support multi-dimensional arrays in C array conversion
    - Enhanced `to_c_array_and_copy` function to handle multi-dimensional Python lists.
    - Added recursive formatting for nested arrays, maintaining proper indentation and line breaks.
    - Updated wave generation functions to allow for different modes of waveform generation (SPWM, THI, SVM).
    - Removed unnecessary print statements for full C array definition.
    - Adjusted example data to include multiple waveforms for C array conversion.
2025-08-08 Implement code changes to enhance functionality and improve performance
2025-08-08 fix: SIN_V配列の不要な空行削除
    LUT.hファイルのSIN_V配列から不要な空行を削除。コードの可読性向上。
2025-08-08 Refactor voltage coefficient calculations in pwm_controller.h
    - Updated the power coefficients for voltage calculations in the calculate_voltage_coefficient function.
    - Adjusted the exponent from 4 to 3 for better accuracy in the calculations.
    - Modified the conditional checks for mVoltage thresholds to improve clarity and maintainability.
2025-08-08 fix: コメントの表記を修正
    LUT.hファイルのコメントにおいて、表記の修正を行った。
2025-08-08 fix: 波形関数の戻り値を修正
    グラフ描画部分を改善し、ステッププロットを使用して波形を表示するように修正。表示のスタイルを調整し、グリッド線のスタイルを追加。
2025-08-08 fix: 不要なインクルードの削除
    LUT.hから<avr/interrupt.h>、<avr/io.h>、<avr/pgmspace.h>のインクルードを削除
2025-08-08 fix: 不要なインクルードの削除
    VVVF_ArduinoMicro.inoからstdint.hのインクルードを削除
2025-08-08 fix: 不要な空白の削除
    pwm_controller.hのUpdatePwmMode関数内で、modulation_indexの計算式から不要な改行を削除
2025-08-08 fix: 設定ファイルにファイル関連付けを追加
    .vscode/settings.jsonに"limits"と"algorithm"のファイル関連付けを追加。
    VVVF_ArduinoMicro.inoのupdate_duties_and_set_ocr関数に出力コンペアレジスタ設定のコメントを追加。
2025-08-08 fix: タイマ設定のコメントを修正
    VVVF_ArduinoMicro.inoのsetup_timer1_3phase関数内のTCCR1B設定に関するコメントを修正。ISR(TIMER3_COMPA_vect)内のコメントを更新し、update呼び出しの頻度を明示。
2025-08-08 aaaaaa
2025-08-08 fix: コードのインデントを修正
    VVVF_ArduinoMicro.inoのインデントを統一し、可読性を向上させるための修正を行った。
2025-08-08 fix: PWM設定の計算式を修正
    pwm_controller.hのUpdatePwmMode関数内で、incrementの計算式を修正し、256からSIN_LENGTHに変更。
2025-08-08 324546789
2025-08-08 fix: fSigの最大値を制限する処理を追加
    - pwm_controller.hにて、fSigの最大値をMAX_FSIGで制限する処理を追加
2025-08-08 fix: 出力コンペアレジスタの設定を修正
    VVVF_ArduinoMicro.inoのupdate_duties_and_set_ocr関数において、出力コンペアレジスタの設定を修正。duty_u、duty_v、duty_wの計算式を簡略化。
2025-08-08 fix: 過変調時のキャリア周波数計算を修正
    VVVF_ArduinoMicro.inoのupdate関数内で、過変調になった場合でも平均スイッチ回数を一定に保つためのコメントを追加。
2025-08-08 VVVF_ArduinoMicro.ino の更新
2025-08-08 fix: 不要な出力データの削除とコメントの追加
    VVVF_ArduinoMicro.ino: コメントを追加し、ピンの役割を明示化
    m2a.py: 正弦波PWMの計算式を修正
    output.csv: 不要なデータを削除し、新しいデータを追加
2025-08-08 fix: 量子化誤差低減のためのコメント追加
    pwm_controller.h の calculate_voltage_coefficient 関数内に量子化誤差低減のための処理に関するコメントを追加
2025-08-08 fix: 過変調時のキャリア周波数計算の修正
    update関数内でのキャリア周波数計算を修正。asin関数の引数をmax/minで制限し、過変調時の計算が正しく行われるように変更。
2025-08-08 fix: 過変調時のキャリア周波数計算のコメント修正
    VVVF_ArduinoMicro.inoのupdate関数内の過変調時のキャリア周波数計算に関するコメントを修正。「謎こだわり」という表現を追加。
2025-08-08 安定性向上
2025-08-08 軽量化？
2025-08-08 fix: コメントの追加と修正
    - 概要、ポート/ピン対応、注意事項を詳細に記述
    - ステータス・レジスタの保存と復元に関するコメントを追加
    - fswの初期値を525.0fに変更
2025-08-08 fix: コメントの追加と修正
    VVVF_ArduinoMicro.inoのサンプリングレートに関するコメントを追加。新しいPWM設定を適用する際のコメントを追加。位相アキュムレータの更新処理に関するコメントを修正。デューティー計算のコメントを修正。
2025-08-08 fix: 関数の説明コメント追加
    pwm_controller.hのcalculate_voltage_coefficient関数の後に、UpdatePwmMode関数の説明コメントを追加
2025-08-08 fix: 最大キャリア周波数と最大信号周波数のコメント追加
    pwm_controller.hに最大キャリア周波数と最大信号周波数に関する説明コメントを追加
2025-08-08 ピン配置参考用画像
    ピン配置参考用画像
2025-08-09 fix: 最大キャリア周波数の変更
    VVVF_ArduinoMicro.ino:
    - ステータス・レジスタの保存と復元のコメントを修正
    - PWM設定の適用に関するコメントを修正
    pwm_controller.h:
    - 最大キャリア周波数を1800から2400に変更
2025-08-09 feat: 過変調リニアリティ補正用テーブル生成プログラムの追加
    m2a.pyに過変調リニアリティ補正用テーブル生成プログラムの説明コメントを追加
2025-08-09 注意っていうかさあ、違うじゃん
2025-08-09 fix: エラーメッセージの表示を追加
    m2a.pyの69行目でRuntimeError発生時にエラーメッセージを表示する処理を追加。コードの可読性向上。
2025-08-11 feat: .vscodeディレクトリを.gitignoreに追加 .vscodeディレクトリを無視する設定を追加しました。
2025-08-11 feat: コード変更の追加
    - 新しい機能の実装
    - コードの最適化
2025-08-11 delete: .vscode/settings.jsonの削除 .vscode/settings.jsonファイルを削除したため、プロジェクトの設定がリポジトリから除外された
2025-08-11 feat: .gitignoreにoutput.csvを追加
    .vscode/tasks.jsonを.gitignoreから削除
    output.csvを.gitignoreに追加
2025-08-11 ピン配置.png追加
2025-08-11 Update README.md
    なんかピン配置ないなってた
2025-08-16 fix: 過変調リニアリティ補正の定数修正
    VVVF_ArduinoMicro.ino:
    - 過変調の計算に使用する定数をLUT_ZERO_LEVELに変更。
    pwm_controller.h:
    - SHIFTの定義を修正し、SHIFT_BITを使用して定数を計算するように変更。
    - modulation_indexの計算にLUT_ZERO_LEVELを使用するように修正。
2025-08-16 fix: PWMインクリメント計算の冗長なコメント削除
    pwm_controller.hのUpdatePwmMode関数内で、PWMインクリメント計算の冗長なコメントを削除。
2025-08-16 Refactor code formatting and improve readability in VVVF_ArduinoMicro.ino and pwm_controller.h
    - Adjusted comments and code indentation for better clarity.
    - Enhanced the structure of the `calculate_voltage_coefficient` function for improved readability.
    - Updated the `UpdatePwmMode` function to maintain consistent formatting.
    - Added a .clang-format file to enforce coding style guidelines.
2025-08-16 fix: SvmEnableの初期値を0に変更
    VVVF_ArduinoMicro.inoのsetup関数内で、pmref.SvmEnableの初期値を1から0に変更
2025-08-25 34546576890
2025-09-08 fix: SvmEnableの初期値設定を修正
    VVVF_ArduinoMicro.inoのpmref.SvmEnableの初期値を0に設定。
    pwm_controller.hのUpdatePwmMode関数の引数のポインタ表記を修正。
2025-11-09 「インバータ技術2025年12月号 中学生でも作れる！VVVFインバータの創り方」 付属サンプルプログラム集 に改変
2025-11-09 fix: VVVF_test1の周波数分解能を修正
    本当は7.8Hzでしたごめんなさい
2025-11-09 fix: 周波数の最大値を30から100に変更 VVVF_test1.inoのループ内でfreqの最大値を30から100に変更し、モジュレーションインデックスの計算に影響を与える。
2025-11-10 Implement PWM control for VVVF system with DDS phase accumulator
    - Added main Arduino sketch (VVVF_test2.ino) for PWM generation using phase accumulator technique.
    - Implemented timer setup for 3-phase PWM output and parameter updates.
    - Created PWM controller header (pwm_controller.h) defining LUTs for sine wave generation and PWM configuration structures.
    - Introduced ISR for timer overflow and capture to handle PWM duty cycle updates.
    - Added functions to update PWM mode based on reference parameters and manage signal frequency and modulation index.
2025-11-10 feat: VVVF_test2プログラムの追加
    README.mdにVVVF_test2プログラムの概要を追加。正式な3相PWM生成用プログラムとして位相アキュムレータを使用したバージョンを記述。VVVF_Completedプログラムの説明を補足。
2025-12-07 きばんだ基板
2025-12-10 かいぎょ
